# Repository masa-levs/automorning

File README.md:

automorning
===========

Turns on coffemachine in the morning.

## KiCad design circut/usb_rs485.kicad_pcb

Board: 2 copper layers, 11 parts (0 on the bottom side), 12 nets.

Parts:
C1, C3: C0.1uF; SM0805
C2: C1.0uF; SM1210
CON1: USB-MINI-B; USB_MINI_B
IC1: SP3485CNASM; so-8
P2: CONN_2; C2
R1: 10K; SM1206
R2, R3: 560; SM1206
R4: K4.7; SM1206
U1: CP2102; QFN28

Connections:
/D+: CON1.3, U1.4
/D-: CON1.2, U1.5
/RX: IC1.1, U1.25
/TX: IC1.4, U1.26
/VBUS: C2.2, C3.2, CON1.1, IC1.8, R1.2, R2.1, U1.7, U1.8
/VDD: C1.1, R4.2, U1.6
GND: C1.2, C2.1, C3.1, CON1.5, IC1.5, R3.2, U1.3
unnamed: IC1.2, IC1.3, R1.1, U1.27
unnamed: IC1.7, P2.1, R2.2
unnamed: IC1.6, P2.2, R3.1
unnamed: R4.1, U1.9
unnamed: CON1.6, CON1.7, CON1.8, CON1.9

## KiCad design circut/automorning.kicad_pcb

Parts:
D1: LED
IC1: ATMEGA328P-TQFP32; TQFP32
IC2: SP3485CNASM; SO8
P1, P3: CONN_2
P2: CONN_4
P4: RELEPD5
P5: CONN_2RELEPB4
Q1, Q2: MOSFET_N
R1, R2: 1K
R3: 10K
R4, R5: 560
U1: IRU1015

Connections:
+5V: IC1.4 (VCC), IC1.6 (VCC), IC2.8, Q1.D, Q2.S, R2.2, R4.2, U1.2 (Vout)
+12V: P1.1, U1.3 (Vin)
/DI: IC1.31 ((PCINT17/TXD)PD1), IC2.4, P2.2
GND: IC1.3 (GND), IC1.5 (GND), IC1.21 (GND), IC2.5, P1.2 (PM), P2.3, P4.1, P5.1, R1.2, R3.1, R5.1, U1.1 (Adj)
unnamed: IC1.29 ((PCINT14/~RESET~)PC6), P2.4, R2.1
unnamed: IC1.30 ((PCINT16/RXD)PD0), IC2.1, P2.1
unnamed: D1.2 (K), R1.1
unnamed: IC1.25 ((PCINT10/ADC2)PC2), IC2.2, IC2.3, R3.2
unnamed: IC2.7, P3.1, R4.1
unnamed: IC2.6, P3.2 (PM), R5.2
unnamed: IC1.9 ((PCINT21/OC0B/T1)PD5), Q1.G
unnamed: P4.2 (PM), Q1.S
unnamed: IC1.16 ((PCINT4/MISO)PB4), Q2.G
unnamed: P5.2 (PM), Q2.D
unnamed: D1.1 (A), IC1.23 ((PCINT8/ADC0)PC0)

Board: 2 copper layers, 16 parts (0 on the bottom side), 15 nets.

## Commit log

2014-07-13 Automorning circut added
2014-07-13 kcel update
2014-08-08 USB <-> RS485 circut added
2014-08-08 kcel updated
